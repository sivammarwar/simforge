.title RC Low-Pass Filter
